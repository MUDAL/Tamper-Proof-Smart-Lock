# Keil uVision project smart_lock_rtos.uvprojx, settings and files
target stm32f103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smart_lock_rtos
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .;.\FreeRTOS\source\include;.\FreeRTOS\source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c app.c app.h
  group High Level Lib
    ./: bluetooth.c bluetooth.h button.c button.h eeprom.c eeprom.h fingerprint.c fingerprint.h gsm.c gsm.h ir_sensor.c ir_sensor.h keypad.c keypad.h oled.c oled.h output_device.c output_device.h rtc.c rtc.h system.c system.h
  group FreeRTOS
    ./: FreeRTOSConfig.h
    ./FreeRTOS/Source/: list.c queue.c tasks.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/Source/portable/MemMang/: heap_1.c
  group Low Level Lib
    ./: clock.c clock.h dma.c dma.h gpio.c gpio.h i2c.c i2c.h spi.c spi.h uart.c uart.h
  group Generic
    ./: state.c state.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
